# Keil uVision project F1C100S.uvproj, settings and files
target F1C100S (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: F1C100S
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: ..\Project\BOOT0 ..\Project\obj\F1C100S.bin ..\Project\f1c100s.bin
  c flags: Optim=1 uC99=1 wLevel=2
  c misc: --diag_suppress=1081
  c include: ..\Driver\Include;..\Project
  memory RVCT1: ROM 0x0 size 0x8000
  memory RVCT4: ROM 0x80000000 size 0x10000
  memory RVCT9: RAM 0x80010000 size 0xffffffff
  scatter file: ..\Script\F1C100S.sct
  link misc: --entry 0x00000000
  group src
    ./: main.c main.h
    ../Driver/Source/: standalone.c sys_start.s vectors1.s
  group Libraries
    ../Driver/Source/: sys_clock.c sys_dram.c sys_gpio.c sys_uart.c sys_delay.c sys-spi-flash.c arm32.c sys_lcd.c sys_mmu.c
